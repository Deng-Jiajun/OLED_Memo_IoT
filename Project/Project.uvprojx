# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Source\Hardware;..\Source\Libraries\CMSIS;..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\System;..\Source\User;..\Source\Utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Source/Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Source/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../Source/System/: delay.c usart.c sys.c rcc.c assert_param.c
  group Utils
    ../Source/Utils/: utils_hmac.c utils_md5.c utils_sha1.c cJSON.c
  group Hardware
    ../Source/Hardware/: led.c key.c dht11.c iic.c oled_iic.c wifi.c mqtt.c
  group User
    ../Source/User/: main.c stm32f10x_it.c test.c
